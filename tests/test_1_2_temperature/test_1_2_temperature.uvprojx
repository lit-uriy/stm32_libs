# Keil uVision project test_1_2_temperature.uvprojx, settings and files
target test (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F070RB STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.0
  cpu: CPUTYPE("Cortex-M0")
  output: out +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c misc: -DDEVICE_RTC=1 -DDEVICE_SLEEP=1 -DTOOLCHAIN_object -DTOOLCHAIN_ARM_STD --split_sections -D__ASSERT_MSG -DTARGET_STM32F0 --no_rtti -DDEVICE_PORTINOUT=1 -DTARGET_FF_MORPHO -DDEVICE_I2C_ASYNCH=1 -DTARGET_FF_ARDUINO -c -DDEVICE_SPISLAVE=1 -DDEVICE_PORTOUT=1 -DDEVICE_STDIO_MESSAGES=1 -DTARGET_RELEASE -DTARGET_LIKE_MBED -DDEVICE_SERIAL_FC=1 -DTARGET_LIKE_CORTEX_M0 -DARM_MATH_CM0 -DDEVICE_ANALOGIN=1 -DDEVICE_PORTIN=1 -DTARGET_CORTEX_M --cpu=Cortex-M0 -D__CORTEX_M0 -DDEVICE_I2C=1 --preinclude=../../mbed_config.h -DDEVICE_LOWPOWERTIMER=1 -DTARGET_STM -DTOOLCHAIN_ARM -DDEVICE_INTERRUPTIN=1 --no_depend_system_headers -DTARGET_UVISOR_UNSUPPORTED --md -DDEVICE_PWMOUT=1 -DDEVICE_SERIAL_ASYNCH=1 --gnu -DTRANSACTION_QUEUE_SIZE_SPI=2 --apcs=interwork -DDEVICE_SPI=1 -D__MBED__=1 -DTARGET_NUCLEO_F070RB -DDEVICE_SERIAL=1 -DTARGET_M0 -DDEVICE_I2CSLAVE=1 -D__CMSIS_RTOS -DDEVICE_SPI_ASYNCH=1 -DTARGET_STM32F070RB -D__MBED_CMSIS_RTOS_CM -DMBED_BUILD_TIMESTAMP=1490466442.17
  c include: .; ../../Containers; ../../1Wire; ../../../mbed_DS1820_HelloWorld/mbed/.; ../../../mbed_DS1820_HelloWorld/mbed/TARGET_NUCLEO_F070RB; ../../../mbed_DS1820_HelloWorld/mbed/TARGET_NUCLEO_F070RB/TARGET_STM; ../../../mbed_DS1820_HelloWorld/mbed/TARGET_NUCLEO_F070RB/TARGET_STM/TARGET_STM32F0; ../../../mbed_DS1820_HelloWorld/mbed/TARGET_NUCLEO_F070RB/TARGET_STM/TARGET_STM32F0/TARGET_NUCLEO_F070RB; ../../../mbed_DS1820_HelloWorld/mbed/TARGET_NUCLEO_F070RB/TARGET_STM/TARGET_STM32F0/TARGET_NUCLEO_F070RB/device; ../../../mbed_DS1820_HelloWorld/mbed/TARGET_NUCLEO_F070RB/TARGET_STM/TARGET_STM32F0/device; ../../../mbed_DS1820_HelloWorld/mbed/TARGET_NUCLEO_F070RB/TOOLCHAIN_ARM_STD; ../../../mbed_DS1820_HelloWorld/mbed/drivers; ../../../mbed_DS1820_HelloWorld/mbed/hal; ../../../mbed_DS1820_HelloWorld/mbed/platform
  asm misc: --cpreproc --cpreproc_opts=-D__ASSERT_MSG,-D__CORTEX_M0,-D__CMSIS_RTOS,-D__MBED_CMSIS_RTOS_CM,-DTRANSACTION_QUEUE_SIZE_SPI=2,-DARM_MATH_CM0
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  memory RVCT10: RAM 0x1fffe000 size 0x2000
  scatter file: ../../../mbed_DS1820_HelloWorld/mbed/TARGET_NUCLEO_F070RB/TOOLCHAIN_ARM_STD/stm32f070xb.sct
  group main
    ../../../mbed_DS1820_HelloWorld/: mbed_config.h
    ./: main.cpp
  group mbed
    ../../../mbed_DS1820_HelloWorld/mbed/drivers/: AnalogIn.h AnalogOut.h BusIn.h BusInOut.h BusOut.h CAN.h DigitalIn.h DigitalInOut.h DigitalOut.h DirHandle.h Ethernet.h FileBase.h FileHandle.h FileLike.h FilePath.h FileSystemLike.h FlashIAP.h I2C.h I2CSlave.h InterruptIn.h InterruptManager.h LocalFileSystem.h LowPowerTicker.h LowPowerTimeout.h LowPowerTimer.h PortIn.h PortInOut.h PortOut.h PwmOut.h RawSerial.h Serial.h SerialBase.h SPI.h SPISlave.h Stream.h Ticker.h Timeout.h Timer.h TimerEvent.h
    ../../../mbed_DS1820_HelloWorld/mbed/hal/: analogin_api.h analogout_api.h buffer.h can_api.h can_helper.h dma_api.h Driver_Common.h Driver_Storage.h emac_api.h ethernet_api.h flash_api.h flash_data.h gpio_api.h gpio_irq_api.h i2c_api.h lp_ticker_api.h pinmap.h port_api.h pwmout_api.h rtc_api.h serial_api.h sleep_api.h spi_api.h ticker_api.h trng_api.h us_ticker_api.h
    ../../../mbed_DS1820_HelloWorld/mbed/TARGET_NUCLEO_F070RB/TOOLCHAIN_ARM_STD/: analogin_api.o analogout_api.o can_api.o cmsis_nvic.o gpio_api.o gpio_irq_api.o gpio_irq_device.o hal_tick_16b.o hal_tick_32b.o i2c_api.o lp_ticker.o mbed.ar mbed_board.o mbed_overrides.o mbed_retarget.o PeripheralPins.o pinmap.o port_api.o pwmout_api.o pwmout_device.o rtc_api.o serial_api.o sleep.o spi_api.o startup_stm32f070xb.o stm32f0xx_hal.o stm32f0xx_hal_adc.o stm32f0xx_hal_adc_ex.o stm32f0xx_hal_can.o stm32f0xx_hal_cec.o stm32f0xx_hal_comp.o stm32f0xx_hal_cortex.o stm32f0xx_hal_crc.o stm32f0xx_hal_crc_ex.o stm32f0xx_hal_dac.o stm32f0xx_hal_dac_ex.o stm32f0xx_hal_dma.o stm32f0xx_hal_flash.o stm32f0xx_hal_flash_ex.o stm32f0xx_hal_gpio.o stm32f0xx_hal_i2c.o stm32f0xx_hal_i2c_ex.o stm32f0xx_hal_i2s.o stm32f0xx_hal_irda.o stm32f0xx_hal_iwdg.o stm32f0xx_hal_pcd.o stm32f0xx_hal_pcd_ex.o stm32f0xx_hal_pwr.o stm32f0xx_hal_pwr_ex.o stm32f0xx_hal_rcc.o stm32f0xx_hal_rcc_ex.o stm32f0xx_hal_rtc.o stm32f0xx_hal_rtc_ex.o stm32f0xx_hal_smartcard.o stm32f0xx_hal_smartcard_ex.o stm32f0xx_hal_smbus.o stm32f0xx_hal_spi.o stm32f0xx_hal_spi_ex.o stm32f0xx_hal_tim.o stm32f0xx_hal_tim_ex.o stm32f0xx_hal_tsc.o stm32f0xx_hal_uart.o stm32f0xx_hal_uart_ex.o stm32f0xx_hal_usart.o stm32f0xx_hal_wwdg.o stm32f0xx_ll_adc.o stm32f0xx_ll_comp.o stm32f0xx_ll_crc.o stm32f0xx_ll_crs.o stm32f0xx_ll_dac.o stm32f0xx_ll_dma.o stm32f0xx_ll_exti.o stm32f0xx_ll_gpio.o stm32f0xx_ll_i2c.o stm32f0xx_ll_pwr.o stm32f0xx_ll_rcc.o stm32f0xx_ll_rtc.o stm32f0xx_ll_spi.o stm32f0xx_ll_tim.o stm32f0xx_ll_usart.o stm32f0xx_ll_utils.o stm_spi_api.o sys.o system_stm32f0xx.o trng_api.o us_ticker_16b.o us_ticker_32b.o
    ../../../mbed_DS1820_HelloWorld/mbed/TARGET_NUCLEO_F070RB/: arm_common_tables.h arm_const_structs.h arm_math.h core_ca9.h core_ca_mmu.h core_caFunc.h core_caInstr.h core_cm0.h core_cm0plus.h core_cm3.h core_cm4.h core_cm4_simd.h core_cm7.h core_cmFunc.h core_cmInstr.h core_cmSecureAccess.h core_cmSimd.h core_sc000.h core_sc300.h
    ../../../mbed_DS1820_HelloWorld/mbed/platform/: Callback.h CallChain.h CircularBuffer.h critical.h CThunk.h FunctionPointer.h mbed_application.h mbed_assert.h mbed_critical.h mbed_debug.h mbed_error.h mbed_interface.h mbed_mem_trace.h mbed_preprocessor.h mbed_retarget.h mbed_rtc_time.h mbed_semihost_api.h mbed_sleep.h mbed_stats.h mbed_toolchain.h mbed_wait_api.h platform.h PlatformMutex.h rtc_time.h semihost_api.h SingletonPtr.h sleep.h toolchain.h Transaction.h wait_api.h
    ../../../mbed_DS1820_HelloWorld/mbed/TARGET_NUCLEO_F070RB/TARGET_STM/TARGET_STM32F0/: can_device.h common_objects.h device.h gpio_irq_device.h i2c_device.h pin_device.h pwmout_device.h
    ../../../mbed_DS1820_HelloWorld/mbed/TARGET_NUCLEO_F070RB/TARGET_STM/TARGET_STM32F0/TARGET_NUCLEO_F070RB/device/: cmsis.h cmsis_nvic.h hal_tick.h stm32f070xb.h stm32f0xx.h system_stm32f0xx.h
    ../../../mbed_DS1820_HelloWorld/mbed/TARGET_NUCLEO_F070RB/TARGET_STM/: gpio_object.h mbed_rtx.h PeripheralPins.h PinNamesTypes.h PortNames.h rtc_api_hal.h
    ../../../mbed_DS1820_HelloWorld/mbed/: mbed.h
    ../../../mbed_DS1820_HelloWorld/mbed/TARGET_NUCLEO_F070RB/TARGET_STM/TARGET_STM32F0/TARGET_NUCLEO_F070RB/: objects.h PeripheralNames.h PinNames.h
    ../../../mbed_DS1820_HelloWorld/mbed/TARGET_NUCLEO_F070RB/TARGET_STM/TARGET_STM32F0/device/: stm32_hal_legacy.h stm32f0xx_hal.h stm32f0xx_hal_adc.h stm32f0xx_hal_adc_ex.h stm32f0xx_hal_can.h stm32f0xx_hal_cec.h stm32f0xx_hal_comp.h stm32f0xx_hal_conf.h stm32f0xx_hal_cortex.h stm32f0xx_hal_crc.h stm32f0xx_hal_crc_ex.h stm32f0xx_hal_dac.h stm32f0xx_hal_dac_ex.h stm32f0xx_hal_def.h stm32f0xx_hal_dma.h stm32f0xx_hal_dma_ex.h stm32f0xx_hal_flash.h stm32f0xx_hal_flash_ex.h stm32f0xx_hal_gpio.h stm32f0xx_hal_gpio_ex.h stm32f0xx_hal_i2c.h stm32f0xx_hal_i2c_ex.h stm32f0xx_hal_i2s.h stm32f0xx_hal_irda.h stm32f0xx_hal_irda_ex.h stm32f0xx_hal_iwdg.h stm32f0xx_hal_pcd.h stm32f0xx_hal_pcd_ex.h stm32f0xx_hal_pwr.h stm32f0xx_hal_pwr_ex.h stm32f0xx_hal_rcc.h stm32f0xx_hal_rcc_ex.h stm32f0xx_hal_rtc.h stm32f0xx_hal_rtc_ex.h stm32f0xx_hal_smartcard.h stm32f0xx_hal_smartcard_ex.h stm32f0xx_hal_smbus.h stm32f0xx_hal_spi.h stm32f0xx_hal_spi_ex.h stm32f0xx_hal_tim.h stm32f0xx_hal_tim_ex.h stm32f0xx_hal_tsc.h stm32f0xx_hal_uart.h stm32f0xx_hal_uart_ex.h stm32f0xx_hal_usart.h stm32f0xx_hal_usart_ex.h stm32f0xx_hal_wwdg.h stm32f0xx_ll_adc.h stm32f0xx_ll_bus.h stm32f0xx_ll_comp.h stm32f0xx_ll_cortex.h stm32f0xx_ll_crc.h stm32f0xx_ll_crs.h stm32f0xx_ll_dac.h stm32f0xx_ll_dma.h stm32f0xx_ll_exti.h stm32f0xx_ll_gpio.h stm32f0xx_ll_i2c.h stm32f0xx_ll_iwdg.h stm32f0xx_ll_pwr.h stm32f0xx_ll_rcc.h stm32f0xx_ll_rtc.h stm32f0xx_ll_spi.h stm32f0xx_ll_system.h stm32f0xx_ll_tim.h stm32f0xx_ll_usart.h stm32f0xx_ll_utils.h stm32f0xx_ll_wwdg.h
  group utils
    ../../../mbed_DS1820_HelloWorld/utils/: bin2hex.c bin2hex.h crc.c crc.h
  group YList
    ../../Containers/: ylist.cpp ylist.h
  group 1Wire
    ../../1Wire/: one_wire_device.cpp one_wire_device.h y_ds1820.cpp y_ds1820.h one_wire_rom_code.cpp one_wire_rom_code.h one_wire_mbed_pin.cpp one_wire_mbed_pin.h one_wire.cpp one_wire.h
